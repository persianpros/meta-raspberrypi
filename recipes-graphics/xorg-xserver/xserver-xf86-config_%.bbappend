FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

FILES_${PN}_rpi += "${sysconfdir}/X11/xorg.conf"
