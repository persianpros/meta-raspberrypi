# mesa-demos need libgles1 and userland driver does not have it
COMPATIBLE_HOST_rpi = "null"
