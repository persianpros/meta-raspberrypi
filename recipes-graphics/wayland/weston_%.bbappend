EXTRA_OECONF_append_rpi = " \
    --disable-xwayland-test \
    --disable-simple-egl-clients \
    --disable-resize-optimization \
    --disable-setuid-install \
"
