# I hope it solves the PAK archive (application/x-pak) problem
PACKAGECONFIG_append_rpi = " hls libmms faad"
