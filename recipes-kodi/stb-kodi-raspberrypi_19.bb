require rpi-stb-kodi.inc

COMPATIBLE_MACHINE = "^(raspberrypi)$"
